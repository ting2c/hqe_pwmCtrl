# Keil uVision project SN32F700B_Demo.uvprojx, settings and files
target SN32F700B (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: SN32F705BJ SONiX
  pack: SONiX.SN32F7_DFP.1.4.5
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SN32F700B +hex
  AfterMake: HexConvert.exe SN32F700B "#H" 0
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group UserApp
    ./: main.c CodeOption_SN32F700B.s
  group GPIO
    ./Interface/GPIO/: GPIO.c
  group Utility
    ./Utility/: Utility.c
  group SysTick
    ./SysTick/: SysTick.c
  group UART
    ./UART/: UART0.c UART1.c
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.4
